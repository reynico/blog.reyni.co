options:
  parameters:
    author: nico
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: Receptor FM - Paso 4
  states: {}

blocks:
- name: decimation_rate
  id: variable
  parameters:
    value: '8'
  states: {}
- name: filter_cutoff_freq
  id: variable_qtgui_range
  parameters:
    label: Frecuencia cutoff
    orient: Qt.Horizontal
    start: '10000'
    step: '10000'
    stop: '250000'
    value: '70000'
  states: {}
- name: filter_transition_band
  id: variable_qtgui_range
  parameters:
    label: Banda de transicion
    orient: Qt.Horizontal
    start: '5000'
    step: '5000'
    stop: '100000'
    value: '20000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 101.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: decimation_rate
    quad_rate: samp_rate/decimation_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: sysdefault
    samp_rate: '32000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimation_rate
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, filter_cutoff_freq, filter_transition_band, firdes.WIN_HAMMING)
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '0'
    freq0: freq
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimation_rate
    fc: freq
    fftsize: '1024'
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
