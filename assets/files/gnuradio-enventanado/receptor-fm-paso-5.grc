options:
  parameters:
    author: nico
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: Receptor FM - Paso 5
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: filter_cutoff_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: Frecuencia cutoff
    orient: Qt.Horizontal
    start: '10000'
    step: '10000'
    stop: '250000'
    value: '70000'
  states: {}
- name: filter_transition_band
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1
    label: Banda de transicion
    orient: Qt.Horizontal
    start: '5000'
    step: '5000'
    stop: '100000'
    value: '20000'
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Filtro 1 (centrado)
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: gain2
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: Filtro 2 (- 400 KHz)
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: decimation
    quad_rate: samp_rate/decimation
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: decimation
    quad_rate: samp_rate/decimation
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: sysdefault
    samp_rate: '32000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain1
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, filter_cutoff_freq, filter_transition_band, firdes.WIN_HANN)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-400000'
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, filter_cutoff_freq, filter_transition_band, firdes.WIN_HANN)
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '0'
    freq0: 101.9e6
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_wfm_rcv_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_wfm_rcv_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
